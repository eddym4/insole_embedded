# Keil uVision project ble_app_hrs_s110_with_dfu_experimental_pca10028.uvprojx, settings and files
target nrf51422_xxac_s110 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_DFU_APP_SUPPORT NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT BOARD_PCA10028
  c misc: --c99
  c include: ..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x00016000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../../: main.c
  group Documentation
    ../../../: Abstract.txt license.txt
software components: CMSIS:CORE , Device:Startup 1.0.0, Board Support:bsp 7.2.0, nRF_BLE:BLE_Modules:ble_service_common 1.1.1, nRF_BLE:BLE_Modules:ble_common 1.1.1, nRF_BLE:BLE_Modules:ble_conn_params 1.1.1, nRF_BLE:BLE_Modules:ble_advdata 1.1.1, nRF_BLE:BLE_Modules:device_manager 1.1.1, nRF_BLE:BLE_Services:ble_hrs 1.1.1, nRF_BLE:BLE_Services:ble_dis 1.1.1, nRF_BLE:BLE_Services:ble_bas 1.1.1, nRF_BLE:BLE_Services:ble_dfu 1.1.1, nRF_Drivers:app_uart 1.2.1, nRF_Drivers:nrf_delay 1.2.1, nRF_Drivers:nrf_error 1.2.1, nRF_Drivers:nrf_gpio 1.2.1, nRF_Drivers:pstorage 1.2.1, nRF_Libraries:DFU:dfu_app_handler 1.1.1, nRF_Libraries:DFU:dfu_bootloader_util 1.1.1, nRF_Libraries:app_button 1.1.1, nRF_Libraries:app_error 1.1.1, nRF_Libraries:app_fifo 1.1.1, nRF_Libraries:app_gpiote 1.1.1, nRF_Libraries:app_scheduler 1.1.1, nRF_Libraries:app_timer 1.1.1, nRF_Libraries:app_trace 1.1.1, nRF_Libraries:app_util 1.1.1, nRF_Libraries:ble_sensorsim 1.1.1, nRF_Libraries:nrf_assert 1.1.1, nRF_Libraries:retarget 1.1.1, nRF_SoftDevice:Internal:softdevice_present 1.1.1, nRF_SoftDevice:s110 7.1.0-3, nRF_SoftDevice:Internal:sd_common 1.1.1
