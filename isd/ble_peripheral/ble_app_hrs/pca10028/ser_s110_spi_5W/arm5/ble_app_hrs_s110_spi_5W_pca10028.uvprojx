# Keil uVision project ble_app_hrs_s110_spi_5W_pca10028.uvprojx, settings and files
target nrf51422_xxac_s110 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=4 OneElfS=1
  c define: SPI_MASTER_0_ENABLE NRF51 BLE_STACK_SUPPORT_REQD S110 SVCALL_AS_NORMAL_FUNCTION BOARD_PCA10028
  c misc: --c99
  c include: ..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x39000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../: main.c
  group Documentation
    ../../../: Abstract.txt license.txt
software components: CMSIS:CORE , Device:Startup 1.0.0, Board Support:bsp 7.2.0, nRF_BLE:BLE_Modules:ble_service_common 1.1.1, nRF_BLE:BLE_Modules:ble_common 1.1.1, nRF_BLE:BLE_Modules:ble_conn_params 1.1.1, nRF_BLE:BLE_Modules:ble_advdata 1.1.1, nRF_BLE:BLE_Modules:device_manager 1.1.1, nRF_BLE:BLE_Services:ble_hrs 1.1.1, nRF_BLE:BLE_Services:ble_dis 1.1.1, nRF_BLE:BLE_Services:ble_bas 1.1.1, nRF_Drivers:app_uart 1.2.1, nRF_Drivers:ble_flash 1.2.1, nRF_Drivers:nrf_delay 1.2.1, nRF_Drivers:nrf_error 1.2.1, nRF_Drivers:nrf_gpio 1.2.1, nRF_Drivers:nrf_soc 1.2.1, nRF_Drivers:pstorage 1.2.1, nRF_Drivers:spi_5W_master 1.2.1, nRF_Libraries:app_button 1.1.1, nRF_Libraries:app_error 1.1.1, nRF_Libraries:app_fifo 1.1.1, nRF_Libraries:app_gpiote 1.1.1, nRF_Libraries:app_scheduler 1.1.1, nRF_Libraries:app_timer 1.1.1, nRF_Libraries:app_trace 1.1.1, nRF_Libraries:app_util 1.1.1, nRF_Libraries:ble_sensorsim 1.1.1, nRF_Libraries:nrf_assert 1.1.1, nRF_Libraries:retarget 1.1.1, nRF_Serialization:Internal:serapp_s110 1.1.1, nRF_Serialization:Internal:serapp_mw_s110 1.1.1, nRF_Serialization:Internal:serapp_codecs_s110_ble 1.1.1, nRF_Serialization:Internal:ser_codecs_common 1.1.1, nRF_Serialization:Internal:cond_field_serialization 1.1.1, nRF_Serialization:Internal:ser_codecs_s110_ble_struct 1.1.1, nRF_Serialization:Internal:serapp_codecs_s110_ble_gap 1.1.1, nRF_Serialization:Internal:ser_codecs_s110_ble_gap_struct 1.1.1, nRF_Serialization:Internal:serapp_codecs_s110_ble_gattc 1.1.1, nRF_Serialization:Internal:ser_codecs_s110_ble_gattc_struct 1.1.1, nRF_Serialization:Internal:serapp_codecs_s110_ble_gatts 1.1.1, nRF_Serialization:Internal:ser_codecs_s110_ble_gatts_struct 1.1.1, nRF_Serialization:Internal:serapp_codecs_s110_ble_l2cap 1.1.1, nRF_Serialization:Internal:serapp_codecs_s110_nrf_soc 1.1.1, nRF_Serialization:Internal:ser_sd_transport 1.1.1, nRF_Serialization:Internal:ser_hal_transport 1.1.1, nRF_Serialization:Internal:serapp_hal_power_system_off 1.1.1, nRF_Serialization:Internal:serapp_codecs_s110_ble_evt_mux 1.1.1, nRF_Serialization:Internal:serapp_codecs_s110_ble_gap_evt 1.1.1, nRF_Serialization:Internal:serapp_codecs_s110_ble_gattc_evt 1.1.1, nRF_Serialization:Internal:serapp_codecs_s110_ble_gatts_evt 1.1.1, nRF_Serialization:Internal:serapp_codecs_s110_ble_l2cap_evt 1.1.1, nRF_Serialization:Internal:ser_softdevice_handler 1.1.1, nRF_Serialization:Internal:ser_app_hal 1.1.1, nRF_Serialization:Internal:app_mailbox 1.1.1, nRF_Serialization:ser_phy 1.1.1, nRF_SoftDevice:s110 7.1.0-3, nRF_SoftDevice:Internal:sd_common 1.1.1
